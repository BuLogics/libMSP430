# IAR project FlashWrite_16_BIT.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: CONFIG\lnk430F5438_obj.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    config/: lnk430F5438_obj.xcl
    ./: msp430x5xx_FlashWrite_16_BIT.s43
