<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DcoCal.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\FLLCall.ewp</path>
  </project>
  <batchBuild/>
</workspace>


